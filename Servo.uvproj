# Keil uVision project Servo.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F411 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: Servo +hex
  AfterMake: .\bin\_copyhex.cmd
  c flags: Optimize=9
  c include: ./src
  group Source Group 1
    ./src/: adc.c calibration.c config.c convvalues.c crc.c deadzone.c F410_FlashPrimitives.c interface.c lowpassfilter.c mainloop.c maintimer.c motor.c obuffer.c pid.c properties.c regulator.c rs485.c servo.c adc.h arraysize.h c8051F410.h common.h config.h convvalues.h crc.h deadzone.h F410_FlashPrimitives.h interface.h lowpassfilter.h maintimer.h motor.h obuffer.h pid.h properties.h regulator.h rs485.h STARTUP.A51 stdint.h version.h
